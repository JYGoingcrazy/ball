# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c include: ..\User;..\Hardware;..\Library;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Hardware\VL53L0X\core\inc;..\Hardware\VL53L0X;..\Hardware\VL53L0X\platform\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c systick.c main.c sys.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_dma.c
  group Library
    ../Library/: USART0.c EXTI.c TIMER.c
  group Library/configs
    ../Library/: EXTI_config.h TIMER_config.h USART_config.h
  group Hardware
    ../Hardware/: bsp_servo.c bsp_servo.h bsp_keys.c bsp_keys.h
  group Hardware/VL53L0X
    ../Hardware/VL53L0X/: bsp_VL53L0X.c vl53l0x_cali.c vl53l0x_gen.c vl53l0x_it.c
    ../Hardware/VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
    ../Hardware/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
